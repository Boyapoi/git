<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\pwm2.ewp</path>
  </project>
  <batchBuild />
</workspace>
